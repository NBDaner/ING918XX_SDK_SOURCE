# Keil uVision project voice_remote_ctrl.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x2000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: voice_remote_ctrl +hex
  AfterMake: fromelf.exe --bin -o voice_remote_ctrl.bin ./output/voice_remote_ctrl.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,AUDIO_INPUT=0,AUDIO_CODEC_ALG=1,DEBUG_SBC,DECODE
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x200053c8 size 0x2c38
  group APP
    ./src/: main.c profile.c audio_service.c kb_scan.c audio_input.c pingpong.c audio_adpcm.c audio_sbc.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_adc.c peripheral_pinctrl.c peripheral_gpio.c peripheral_ssp.c peripheral_i2s.c peripheral_pdm.c peripheral_pwm.c peripheral_dma.c
  group Tools
    ../../src/Tools/: att_db_util.c blink.c
software components: CMSIS:CORE 4.3.0
